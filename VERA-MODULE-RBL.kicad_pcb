# Repository gianlucarenzi/Vera-Module-RBL-C64 (continued)

## KiCad design VERA-MODULE-RBL.kicad_pcb (continued)

Board: 4 copper layers, 143.0 x 120.5 mm, 221 parts (57 on the bottom side), 195 nets.

## Code that names these connections

File firmware/MCU/src/main.cpp (part):

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 * =========================================================================== */

/* --- Bank 0 Signals (GPIO 0-31) --- */
#define PIN_PHI2        1    /* CPU Clock Phase 2 (Pin 6) */
#define PIN_RW          2    /* Read/Write, High = Read (Pin 7) */

/* D0-D7: GPIO 4 to 11 (Pins 9-16, contiguous in Bank 0): D0 = GPIO 4 */
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#define PIN_A11         34   /* Address Bit 11 (Pin 39) */
#define PIN_A12         35   /* Address Bit 12 (Pin 40) */
#define PIN_A13         36   /* Address Bit 13 (Pin 41) */
#define PIN_ARESET      37   /* C64 /RESET via U27 open-drain, net ~C64_RESET, pull-down R70 (Pin 42) */
#define PIN_CRESET      38   /* Vera Chip Reset Output (Pin 43) */
#define PIN_CDONE       39   /* Vera Programmed Status Input (Pin 44) */
#define PIN_DEV_SEL_N   40   /* Vera Chip Select Output (Pin 45, active LOW) */
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 * code executes.  The levels must be valid when CHIP_PU rises and for
 * t_H = 3 ms after it (datasheet v2.2, §3, Table 3-2).
 *
 * GPIO0  —  Pin  5  |  Boot mode selection  |  Internal weak PULL-UP 45 kΩ
 *   Net BOOT0: R33 4.7 kΩ pull-up, BOOT button SW3, C61 100 nF, and R54 -> Q4
 *   (auto-reset from the programmer).  Not wired to any C64 signal.
 *   CHIP_PU has R31 4.7 kΩ + C25 1 µF (4.7 ms) against 0.47 ms on GPIO0, so
 *   GPIO0 is already HIGH when the reset is released.
 *   Sampled value: HIGH → SPI boot from embedded flash.  LOW (SW3 or Q4)
 *   → joint download boot, which also needs GPIO46 LOW (see below).
 *
 * GPIO3  —  Pin  8  |  JTAG signal source   |  NO internal pull
 *   Not used by the firmware.  R71 10 kΩ pull-up to 3V3 fixes it HIGH, as the
 *   datasheet requires (§3.4: no internal pull, must not be left floating).
 *   Table 3-5: with the default eFuses GPIO3 is ignored and JTAG goes to the
 *   USB Serial/JTAG Controller; HIGH keeps that choice even if
 *   EFUSE_STRAP_JTAG_SEL is burned, so GPIO39-42 never become JTAG pins.
 *
 * GPIO45 —  Pin 51  |  VDD_SPI voltage      |  Internal weak PULL-DOWN 45 kΩ
 * GPIO46 —  Pin 52  |  ROM messages / download mode | Internal weak PULL-DOWN 45 kΩ
 *   A14 and A15, from the expansion port through U3 (74LVC4245).  The port
 *   address lines are always driven: by the 6510 (which keeps driving them
 *   while in reset) or, during PHI1 and VIC-II DMA, by the VIC-II and the
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 *   PIN_ABUS_OE_N (GPIO47) drives ~OE of U3 and U4, and R7/R34 (10 kΩ to 3V3)
 *   hold it HIGH while the ESP32 is in reset (GPIO47 has no pull and no
 *   power-up glitch).  With U3 disabled its outputs are high-Z and the
 *   internal pull-downs read GPIO45 = GPIO46 = LOW at every chip reset:
 *     GPIO45 LOW → VDD_SPI = 3.3 V from VDD3P3_RTC (Table 3-4), the voltage
 *                  of the FN8 in-package flash (HIGH = 1.8 V: no boot);
 *     GPIO46 LOW → ROM messages suppressed; together with GPIO0 LOW it gives
 *                  the joint download boot (GPIO0 LOW + GPIO46 HIGH is
 *                  invalid), so flashing works with the C64 running.
 *   setup() drives PIN_ABUS_OE_N LOW long after the 3 ms hold time; until
 *   then A0-A15 read as LOW or floating: the bus loop starts only afterwards.
 *   Disabling U4 as well also avoids driving GPIO12-19 against U4 during
 *   their power-up glitches (Table 2-2).
 */

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 * (ee.get_gpio_in / ee.wr_mask_gpio_out bypass the APB bus: ~1 cycle).
 *
 * Input channels  (bit index in cpu_ll_read_dedic_gpio_in() result):
 *   Ch 0 = PHI2 (GPIO 1), Ch 1 = R/W (GPIO 2), Ch 2 = /IO1 (GPIO 41),
 *   Ch 3 = /IO2 (GPIO 42)
 *   The GPIO matrix feeds the dedicated inputs without taking the pins away:
 *   the same signals stay visible in GPIO.in / GPIO.in1.
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}

/*
 * PHI2 edge waits: one ee.get_gpio_in and one bit branch per sample
 * (3 cycles), the shortest polling loop.
 */
static inline __attribute__((always_inline)) void wait_phi2_high(void)
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     * Input  bundle: [PHI2, R/W, /IO1, /IO2]  → input  ch 0-3
     * Output bundle: [DEV_SEL_N]              → output ch 0
     */
    static const int dedic_in_pins[]  = { PIN_PHI2, PIN_RW, PIN_IO1_N, PIN_IO2_N };
    static const int dedic_out_pins[] = { PIN_DEV_SEL_N };
    dedic_gpio_bundle_handle_t dedic_in_bundle, dedic_out_bundle;
    const dedic_gpio_bundle_config_t in_cfg =
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         *   2. one APB read of GPIO.in (A0-A7; no memw: the last store, the
         *      bus release, left in the previous PHI1);
         *   3. /IO2: c = io2_cur[A0-A7], DEV_SEL_N for this cycle with one
         *      ee.wr_mask_gpio_out (the VERA strobes are gated by PHI2 in
         *      hardware);
         *   4. /IO1 read: drive win[A0-A7] at once.  U19 passes it to the C64
         *      because /IO1 enables it (hardware gating).
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        {
            /* VERA drives the bus: sample it just before PHI2 falls. */
            uint32_t last = lo, now;
            while ((now = GPIO.in) & (1UL << PIN_PHI2))
                last = now;
            log_send(EVT_REG, (uint8_t)off8, decode_data(last), 0x00u);
        }
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    cfg.mode         = GPIO_MODE_INPUT;

    /* Bank 0 inputs: PHI2, RW, D0-D7, A0-A9 */
    cfg.pin_bit_mask = (1ULL << PIN_PHI2) | (1ULL << PIN_RW) | DBUS_MASK | ABUS_LO_MASK;
    gpio_config(&cfg);

    /* Bank 1 inputs: A10-A15 (wired, not needed for decode), /IO1, /IO2, CDONE */
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